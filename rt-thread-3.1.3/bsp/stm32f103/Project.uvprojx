# Keil uVision project Project.uvprojx, settings and files
target STM32F103C8 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103-msh
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: libraries/STM32F1xx_HAL_Driver/Inc;libraries/STM32F1xx_HAL_Driver/Inc/Legacy;libraries/CMSIS/Device/ST/STM32F1xx/Include;libraries/CMSIS/Include;.\drivers;..\..\..\uCOS-III_Wrapper\uC-CPU;..\..\..\uCOS-III_Wrapper\uCOS-III;..\..\..\uCOS-III_Wrapper\uC-LIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Applications
    applications/: main.c
  group STM32-HAL
    ./libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s startup_stm32f103xe.s
    libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
    libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group uCOS-III_Wrapper/uC-CPU
    ../../../uCOS-III_Wrapper/uC-CPU/: cpu.h cpu_cfg.h cpu_def.h cpu_core.h cpu_a.c cpu_core.c
  group uCOS-III_Wrapper/uCOS-III
    ../../../uCOS-III_Wrapper/uCOS-III/: os.h os_type.h os_cfg.h os_cfg_app.h os_app_hooks.h os_cfg_app.c os_app_hooks.c os_cpu_c.c os_rtwrap.c os_dbg.c os_core.c os_flag.c os_mutex.c os_q.c os_sem.c os_stat.c os_task.c os_time.c os_tmr.c os_mem.c os_var.c
  group uCOS-III_Wrapper/uC-LIB
    ../../../uCOS-III_Wrapper/uC-LIB/: lib_cfg.h lib_def.h lib_ascii.c lib_ascii.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uCOS-III_Wrapper/examples
    ../../../uCOS-III_Wrapper/examples/: mutex_example.c q_example.c sem_example.c task_sem_example.c timer_example.c
target STM32F103RB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103-msh
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103RC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103-msh
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
software components: CMSIS:CORE 5.4.0, RTOS:kernel 3.1.3, RTOS:shell 3.1.3
